## Config.in
```kconfig
config BR2_PACKAGE_ZBAR_TEST
  bool "zbar-test"
  select BR2_PACKAGE_LIBUNIFIED_LOGGER
  select BR2_PACKAGE_QT5BASE
```
